# IAR project JoystickController.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\stm8\inc\c; D:\development\GitHub\Arm\Programms\Joystick\lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: JoystickController.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: JoystickController.out
  group (top)
    ./: main.c
